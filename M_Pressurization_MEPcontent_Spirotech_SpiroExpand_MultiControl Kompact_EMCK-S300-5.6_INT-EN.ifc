Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_EMCK-S300-5.6_INT-EN.ifc
Time: 2025-08-05T18:21:31+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN:EMCK-S300-5.6, M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN:EMCK-S300-5.6:1803062
In: F00
Type - Material: Color RGB 115-115-115, Color RGB 255-255-255, Color RGB 055-055-055, Color RGB 040-040-040, Color RAL 1003, Color RGB 250-000-000, Color RGB 200-200-200, Color RGB 181-166-066
Type - Other - Category: Mechanical Equipment; EMCK-125 Expansion Vessel: no; EMCK-200 Expansion Vessel: no; EMCK-300 Expansion Vessel: yes; EMCK-45 Expansion Vessel: no; EMCK-500 Expansion Vessel: no; EMCK-75 Expansion Vessel: no; Family Name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN; Vessel 1 Diameter: 600 mm; Vessel 1 Drain Position-Back: 577 mm; Vessel 1 Drain Position-Elevation: 1054.62 mm; Vessel 1 Drain Position-Right: 267.78 mm; Vessel 1 Drain Revolve Start Angle: 0 deg
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 1026 mm; Drain Diameter: 50 mm; Height: 1577 mm; Hydronic Diameter: 25.4 mm; Refill Diameter: 12.7 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Electrical Engineering - Voltage: 230 V
Type - Electrical - Loads - Power: 600 W
Type - Identity Data - Article Description: MultiControl Kompact Solo - 300 l - 5.6 bar; Article Type: EMCK-S300-5.6; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: MultiControl Kompact Solo - 300 l - 5.6 bar; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 12.18; GLN: 8717811000007; GTIN: 8717811043066; Manufacturer: Spirotech; Manufacturer Art. No.: EMCK-S300-5.6; Manufacturer URL: https://www.spirotech.com/8717811043066; MEPcontent Class: VACUUM_DEGASSER; Model: EMCK-S300-5.6; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCK-S300-5.6; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Gray: Color RGB 115-115-115; Gray: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Light Yellow: Color RGB 181-166-066; Red: Color RGB 250-000-000; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Mechanical - Maximum Installation Volume: 0.3 m3; Maximum Water / Glycol (%): 35; Temperature Range (°C): 0-70; Weight: 129 kg
Type - Mechanical - Loads - Workload: 5.6 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCK-S300-5.6; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EMCK-S300-5.6
Other - EMCK Depth: 462.24 mm; EMCK Overflow Pipe Angle: 90 deg; Family: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN; Family and Type: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN: EMCK-S300-5.6; Overflow Connection Elevation: 199.261 mm; Overflow Sets Offset: 104.7 mm; Service Space Depth: 1021.64 mm; Service Space Height: 1572.81 mm; Service Space Position 1: 328.31 mm; Service Space Position 2: 300 mm; Type: EMCK-S300-5.6; Type Id: 1803016; Vessel 1 Center Axis: 331.83 mm; Vessel 1 Overflow Set Position: 45 mm; Vessel 1 Overflow Set Type: no
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 18.077 m2; Volume: 0.699409 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined,Sanitary,Power
Mechanical - Flow - Drain Fixture Units Vessel: 0; Flow In: 0 m3/s; Flow Out: 0 m3/s; Refill Flow: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Left Sided Connections: no; Right Sided Connections: yes; Show Service Area: no

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
InPort_1803062_1 | SINK | PIPE
InPort_1803062_2 | SINK | PIPE
OutPort_1803062_3 | SOURCE | PIPE
OutPort_1803062_4 | SOURCE | PIPE | SystemType: SEWAGE
Port_1803062_8 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
